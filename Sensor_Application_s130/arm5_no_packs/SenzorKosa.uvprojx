# Keil uVision project SenzorKosa.uvprojx, settings and files
target Application_nRF51822_xxAA_s130 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.7.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SenzorKosa
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Sensor setup
    ./source/: Custom_Board.h Setup.h
  group Application
    ./source/: main.c
  group Sensor
    ./source/: Sensor_Modulate.c Sensor_Read.c
  group nRF_BLE
    ../../../nRF5_SDK/v11.0.0/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../nRF5_SDK/v11.0.0/components/ble/ble_advertising/: ble_advertising.c
    ../../../nRF5_SDK/v11.0.0/components/ble/ble_dtm/: ble_dtm.c
    ../../../nRF5_SDK/v11.0.0/components/ble/device_manager/: device_manager_peripheral.c
  group nRF_Drivers
    ../../../nRF5_SDK/v11.0.0/components/drivers_nrf/hal/: nrf_adc.c
    ../../../nRF5_SDK/v11.0.0/components/drivers_nrf/delay/: nrf_delay.c
    ../../../nRF5_SDK/v11.0.0/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../nRF5_SDK/v11.0.0/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../nRF5_SDK/v11.0.0/components/drivers_nrf/rng/: nrf_drv_rng.c
    ../../../nRF5_SDK/v11.0.0/components/drivers_nrf/timer/: nrf_drv_timer.c
    ../../../nRF5_SDK/v11.0.0/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../nRF5_SDK/v11.0.0/components/drivers_nrf/pstorage/: pstorage.c
    ../../../nRF5_SDK/v11.0.0/components/drivers_nrf/spi_master/: spi_5W_master.c
    ../../../nRF5_SDK/v11.0.0/components/drivers_nrf/clock/: nrf_drv_clock.c
  group nRF Libraries
    ../../../nRF5_SDK/v11.0.0/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c nrf_log.c
    ../../../nRF5_SDK/v11.0.0/components/libraries/fifo/: app_fifo.c
    ../../../nRF5_SDK/v11.0.0/components/libraries/scheduler/: app_scheduler.c
    ../../../nRF5_SDK/v11.0.0/components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../../../nRF5_SDK/v11.0.0/components/libraries/trace/: app_trace.c
    ../../../nRF5_SDK/v11.0.0/components/libraries/uart/: app_uart.c
    ../../../nRF5_SDK/v11.0.0/components/libraries/fstorage/: fstorage.c
    ../../../nRF5_SDK/v11.0.0/components/drivers_nrf/ppi/: nrf_drv_ppi.c
